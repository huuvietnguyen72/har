// Bố cục màn OLED 128x64, viết bằng API C của U8g2 để dùng chung cho firmware (display.cpp)
// và chương trình xem trước trên máy tính (vẽ khung hình ra ảnh, không cần ESP32).
#pragma once
#ifdef ARDUINO
#include <U8g2lib.h>
#else
#include "u8g2.h"
#endif
#include <math.h>
#include <stdio.h>
#include <string.h>

enum { OLED_IDLE = 0, OLED_SUSPECTED = 1, OLED_CONFIRMED = 2 };

typedef struct {
  const char* conn;      // "MQTT", "WiFi..", "noWiFi"
  int ntpOk;             // 0 -> thêm "noNTP"
  const char* right;     // góc phải dòng trên: "85%" (pin) hoặc "14:35" (giờ) hoặc ""
  int alarm;             // OLED_IDLE / OLED_SUSPECTED / OLED_CONFIRMED
  int alarmLeftS;        // số giây còn lại để hủy (khi OLED_SUSPECTED)
  int recording;         // đang thu dataset
  const char* label;     // nhãn thô từ Pi ("lie", "stairs_up"...), "" = chưa có
  float conf;            // NAN = chưa có
  const char* ssid;      // tên Wi-Fi (dòng thứ hai), NULL/"" = không hiện
} OledView;

static inline const char* oledLabelEn(const char* l) {
  if (!l || !l[0]) return "...";
  if (!strcmp(l, "stand")) return "Stand";
  if (!strcmp(l, "sit")) return "Sit";
  if (!strcmp(l, "lie")) return "Lie";
  if (!strcmp(l, "walk")) return "Walk";
  if (!strcmp(l, "run")) return "Run";
  if (!strcmp(l, "stairs_up")) return "Stairs up";
  if (!strcmp(l, "stairs_down")) return "Stairs down";
  if (!strcmp(l, "fall")) return "Fall!";
  return l;
}

// Chọn font lớn nhất trong danh sách mà chuỗi vừa chiều rộng maxW
static inline void oledFitFont(u8g2_t* u, const uint8_t* const* fonts, int n, const char* s, int maxW) {
  for (int i = 0; i < n; i++) {
    u8g2_SetFont(u, fonts[i]);
    if (u8g2_GetUTF8Width(u, s) <= maxW) return;
  }
}

static inline void oledCenter(u8g2_t* u, int y, const char* s) {
  const int w = u8g2_GetUTF8Width(u, s);
  u8g2_DrawUTF8(u, w >= 128 ? 0 : (128 - w) / 2, y, s);
}

static inline void oledDraw(u8g2_t* u, const OledView* v) {
  char left[24], body[40];
  u8g2_ClearBuffer(u);
  u8g2_SetFontPosBaseline(u);

  // --- Dòng 1: kết nối bên trái, pin hoặc giờ bên phải (chữ thường, cỡ lớn nhất vừa màn) ---
  static const uint8_t* const statusFonts[] = {u8g2_font_helvR14_tr, u8g2_font_helvR12_tr, u8g2_font_helvR10_tr};
  // Một từ theo từng bước: noWiFi -> WiFi.. -> NTP.. (có MQTT, chờ giờ từ Pi) -> MQTT (sẵn sàng)
  snprintf(left, sizeof(left), "%s", (!v->ntpOk && !strcmp(v->conn, "MQTT")) ? "NTP.." : v->conn);
  for (int i = 0; i < 3; i++) {  // font lớn nhất mà hai bên còn cách nhau ≥ 8 px
    u8g2_SetFont(u, statusFonts[i]);
    if (u8g2_GetStrWidth(u, left) + 8 + u8g2_GetStrWidth(u, v->right) <= 128) break;
  }
  int y = u8g2_GetAscent(u);
  u8g2_DrawStr(u, 0, y, left);
  if (v->right[0]) u8g2_DrawStr(u, 128 - u8g2_GetStrWidth(u, v->right), y, v->right);

  // --- Dòng 2: tên Wi-Fi (không hiện khi đang cảnh báo, để đủ chỗ cho 2 dòng tiếng Việt) ---
  if (v->alarm == OLED_IDLE && v->ssid && v->ssid[0]) {
    static const uint8_t* const ssidFonts[] = {u8g2_font_helvR10_tr, u8g2_font_helvR08_tr};
    snprintf(body, sizeof(body), "WiFi: %s", v->ssid);
    oledFitFont(u, ssidFonts, 2, body, 128);
    size_t len = strlen(body);  // tên quá dài: bớt ký tự cuối, thêm ".."
    while (len > 8 && u8g2_GetStrWidth(u, body) > 128) {
      len--;
      body[len - 2] = '.';
      body[len - 1] = '.';
      body[len] = '';
    }
    y += 3 + u8g2_GetAscent(u);
    u8g2_DrawStr(u, 0, y, body);
  }
  const int lineY = y + 3;
  u8g2_DrawHLine(u, 0, lineY, 128);
  const int top = lineY + 1, h = 64 - top;  // vùng thân

  // --- Cảnh báo té: tiếng Việt có dấu (unifont 16 px), 2 dòng ---
  if (v->alarm != OLED_IDLE) {
    u8g2_SetFont(u, u8g2_font_unifont_t_vietnamese2);
    if (v->alarm == OLED_SUSPECTED) {
      oledCenter(u, top + h / 2 - 2, "NGHI TÉ NGÃ!");
      snprintf(body, sizeof(body), "Nhấn để hủy %ds", v->alarmLeftS < 0 ? 0 : v->alarmLeftS);
      oledCenter(u, 62, body);
    } else {
      oledCenter(u, top + h / 2 - 2, "ĐÃ GỬI CẢNH BÁO");
      oledCenter(u, 62, "Nhấn để tắt còi");
    }
    return;
  }

  // --- Hoạt động: "Lie (70%)" — nhãn và % tin cậy cùng một cỡ chữ, canh giữa thân màn ---
  static const uint8_t* const bodyFonts[] = {u8g2_font_helvR12_tr, u8g2_font_helvR10_tr, u8g2_font_helvR08_tr};
  if (!isnan(v->conf))
    snprintf(body, sizeof(body), "%s%s (%d%%)", v->recording ? "REC " : "", oledLabelEn(v->label),
             (int)(v->conf * 100 + 0.5f));
  else
    snprintf(body, sizeof(body), "%s%s", v->recording ? "REC " : "", oledLabelEn(v->label));
  oledFitFont(u, bodyFonts, 3, body, 128);
  const int asc = u8g2_GetAscent(u);
  oledCenter(u, top + (h + asc) / 2, body);
}
